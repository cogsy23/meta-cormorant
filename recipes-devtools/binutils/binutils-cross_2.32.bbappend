FILESEXTRAPATHS_prepend := "${THISDIR}/binutils:"

SRC_URI += "file://0001-Remove-phase-checks-for-ORIGIN-and-LENGTH-.patch"
